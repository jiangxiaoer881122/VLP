## build/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "d:/nrf52/project/adc/boards/shields/*/Kconfig.defconfig"
osource "C:/ncs/v2.5.0/nrf/boards/shields/*/Kconfig.defconfig"
```
